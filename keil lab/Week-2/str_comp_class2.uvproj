# Keil uVision project str_comp_class2.uvproj, settings and files
target Target 1 (ARM-ADS)
  device: ARM9E-S (Little Endian) ARM
  cpu: CLOCK(60000000) CPUTYPE(ARM9E)
  output: str_comp_class2
  c flags: Optim=1
